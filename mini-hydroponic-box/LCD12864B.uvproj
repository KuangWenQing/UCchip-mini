# Keil uVision project LCD12864B.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD12864B +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\LCD12864B;.\HARDWARE\DS18B20;.\HARDWARE\DHT11
  group HARDWARE
    ./HARDWARE/LCD12864B/: lcd12864.c
    ./HARDWARE/DS18B20/: temp.c
    ./HARDWARE/DHT11/: DHT11.C
  group USER
    ./USER/: main.c
